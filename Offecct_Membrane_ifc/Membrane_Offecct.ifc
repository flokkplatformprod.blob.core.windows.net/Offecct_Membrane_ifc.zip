Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: membrane.ifc
Time: 2016-04-11T15:47:58
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2015
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Membrane
ePset_BIMobject_Lena - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Membrane; SKU (BO_prodsku): Membrane; ManufacturName (BO_Manufac): Offecct; ProductFamily (BO_prodfam): Furniture; ProductGroup (BO_prodgroup): table; ManufacturCountry (BO_mancont): Sweden; DesignCountry (BO_designcont): Sweden; EditionNumber (BO_edinum): 1; Width (BO_width): 350; Height (BO_height): 350; Depth (BO_depth): 110; Weight (BO_weight): 1.9; QR (BO_boqrurl): http://bimobject.com/offecct/product/Membrane; ProductDataUrl (BO_prodaturl): bimobject.com/offecct/product/Membrane; TechnicalDescription (BO_techcert): http://www.offecct.se/files/downloads/Prodblad_eng/OFFECCT_MEMBRANE_EN_LOW.pdf; MaterialMain (BO_mainmat): Polyester; MaterialSecondary (BO_secmat): Polyester; BimObjectCategory (BO_bocat): Furniture; IfcClassification (BO_ifcclas): Furniture; UnspcCode (BO_unspc): 56; RegionEurope (BO_europe): AL, AT, AX, BA, BE, BG, CH, CS, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GR, HR, HU, IE, IS, IT, JE, LI, LT, LU, LV, MC, ME, NL, NO, PL, PT, RO, RS, RU, SE, SI, SK, UA, XK; RegionNorthAmerica (BO_northamerica): AW, BB, BS, CA, CR, GT, HN, JM, MX, PA, PR, SX, TT, US, VG, VI; RegionSouthAmerica (BO_southamerica): AR, BR, CL, CO, EC, FK, PE, PY, UY, VE; RegionMiddleEast (BO_middleeast): AE, BH, EG, IL, IR, JO, KW, LB, OM, PS, QA, SA, TR; RegionAsia (BO_asia): AZ, BD, CN, HK, ID, IN, JP, KH, KR, KZ, MV, MY, PH, SG, TH, TW, VN; RegionOceania (BO_oceania): AU, NZ, PF; RegionAfrica (BO_africa): LR, MA, MU, SC, TN, TZ, ZA
